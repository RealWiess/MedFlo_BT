# Keil uVision project mdk_clang.uvprojx, settings and files
target zephyr (6190000::V6.19::ARMCLANG)
  device: ARMCM4 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: zephyr
  AfterMake: UserCommand.bat "!L" "$K\ARM"
  AfterMake: PackCommand.bat
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c misc: -imacros./linker_conf.h -nostdlib -Wno-section
  c include: ..\src\include
  asm define: _ASMLANGUAGE
  asm misc: -imacros./linker_conf.h -imacros../src/include/autoconf.h
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: linker_pass_final.sct
  link misc: --no_startup --entry __start --keep=_irq_vector_table --keep=__init_* --keep=__device_* --keep=ksdfs.o(.ksdfs) --via linker_flag.txt
  group app
    ../src/main/: main.c common.c msg_manager.c
    ../src/main/gpio/: gpio_test.c
    ../src/main/I2C/: i2c_test.c
    ../src/main/nvram/: nvram_test.c
    ../src/main/spi/: spi_test.c
    ../src/main/uart_pipe/: uart_pipe_test.c
    ../src/main/adc/: adc_test.c
    ../src/main/pwm/: pwm_test.c
    ../src/actions/: bt_le_op.c gpio_control.c rtc_op.c ble_data_test_sample.c ble_super_service.c nvram.c
  group app_system
    ../src/main/: sys_monitor.c sys_wakelock.c sys_standby.c
  group aarch32
    ../../../arch/common/: isr_tables.c sw_isr_common.c
    ../../../arch/arm/core/offsets/: offsets.c
    ../../../arch/arm/core/aarch32/: swap.c swap_helper.S irq_manage.c thread.c cpu_idle.S fatal.c nmi.c nmi_on_reset.S prep_c.c unwind.c isr_wrapper.S
  group aarch32__cortex_m
    ../../../arch/arm/core/aarch32/cortex_m/: vector_table.S reset.S fault_s.S fault.c exc_exit.S scb.c irq_init.c thread_abort.c
    ../../../arch/arm/core/aarch32/cortex_m/mpu/: arm_mpu.c
  group soc
    ../../../soc/arm/actions/tai/: soc.c soc_pm.c soc_reset.c soc_clock.c soc_pinmux.c spicache.c soc_boot.c soc_memctrl.c soc_se_trng.c
    ../../../soc/arm/actions/tai/soc_sleep/src/: soc_sleep_cfg.c
    ../../../soc/arm/actions/tai/soc_efuse/obj/: soc_efuse_r.o
    ../../../soc/arm/actions/tai/soc_sleep/obj/: policy_sleep.o soc_power.o soc_sleep.o soc_sleep_1.o
  group board
    ../../../boards/arm/tai_evb/: board.c ksdfs.s
  group kernel
    ../../../kernel/: device.c errno.c fatal.c idle.c init.c kheap.c mem_slab.c mutex.c queue.c sched.c sem.c stack.c system_work_q.c thread.c thread_abort.c version.c work_q.c condvar.c smp.c banner.c xip.c timeout.c timer.c poll.c mempool.c
  group drivers
    ../../../drivers/timer/: sys_clock_init.c acts_timer.c
    ../../../drivers/serial/: uart_acts.c
    ../../../drivers/gpio/: gpio_acts.c
    ../../../drivers/dma/: vdma_acts.c
    ../../../drivers/spi/: spi_acts.c
    ../../../drivers/flash/: spi_flash_acts.c flash_page_layout.c
    ../../../drivers/nvram/: nvram_config.c nvram_storage.c
    ../../../drivers/pwm/: pwm_tai_acts.c
    ../../../drivers/i2c/: i2c_acts.c
    ../../../drivers/input/: mxkeypad_acts.c
    ../../../drivers/console/: uart_pipe.c
    ../../../drivers/ipmsg/tai/: ipmsg_btc.c
  group lib__os
    ../../../lib/os/: cbprintf.c crc32_sw.c crc16_sw.c crc8_sw.c crc7_sw.c dec.c fdtable.c hex.c notify.c printk.c onoff.c rb.c sem.c thread_entry.c timeutil.c work_q.c heap.c heap-validate.c cbprintf_complete.c ring_buffer.c
    ../../../subsys/logging/: log_minimal.c
    ../../../subsys/net/lib/utils/: addr_utils.c
    ../../../subsys/settings/src/: settings_store.c settings.c settings_init.c settings_nvram.c
    ../../../subsys/sdfs/: sdfs.c
    ../../../subsys/trace/: show_thread.c
    ../../../subsys/partition/: partition.c
    ../../../subsys/fw_version/: fw_version.c
    ../../../drivers/console/: uart_console.c
    ../../../ext/crypto/tinycrypt/lib/source/: utils.c aes_decrypt.c aes_encrypt.c cmac_mode.c sha256.c hmac.c hmac_prng.c
    ../../../subsys/power/: power.c device.c
    ../../../soc/arm/common/cortex_m/: arm_mpu_regions.c
  group lib__libc
    ../../../lib/libc/minimal/source/stdlib/: abort.c atoi.c strtol.c strtoul.c malloc.c bsearch.c exit.c
    ../../../lib/libc/minimal/source/string/: strncasecmp.c strstr.c strspn.c string.c string.S
    ../../../lib/libc/minimal/source/stdout/: stdout_console.c sprintf.c fprintf.c
    ../../../lib/libc/minimal/source/time/: gmtime.c
  group lib
    ../../../lib/posix/: nanosleep.c pthread_common.c
    ../../../lib/rbuf/: rbuf_core.c rbuf_init.c rbuf_pool.c
    ../../../lib/crc/: crc.c
  group subsys__bluetooth
    ../../../subsys/bluetooth/common/: dummy.c log.c rpa.c
    ../../../subsys/bluetooth/host/: settings.c uuid.c addr.c buf.c hci_core.c hci_common.c crypto.c conn.c l2cap.c att.c gatt.c smp.c keys.c
    ../../../drivers/bluetooth/: bt_drv.c hci_acts.c
  group subsys__net
    ../../../subsys/net/: buf.c
